IMAGE_INSTALL:append = " axi-uart-loopback-test"
